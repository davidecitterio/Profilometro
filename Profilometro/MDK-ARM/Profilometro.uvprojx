# Keil uVision project Profilometro.uvprojx, settings and files
target Profilometro (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F767ZITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: Profilometro
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx
  c misc: --C99
  c include: ../Inc;        ../Middlewares/Third_Party/LwIP/src/include;        ../Middlewares/Third_Party/LwIP/system;        ../Drivers/STM32F7xx_HAL_Driver/Inc;        ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;        ../Middlewares/Third_Party/LwIP/src/apps/httpd;        ../Drivers/CMSIS/Device/ST/STM32F7xx/Include;        ../Middlewares/Third_Party/LwIP/src/include/lwip;        ../Middlewares/Third_Party/LwIP/src/include/lwip/apps;        ../Middlewares/Third_Party/LwIP/src/include/lwip/priv;        ../Middlewares/Third_Party/LwIP/src/include/lwip/prot;        ../Middlewares/Third_Party/LwIP/src/include/netif;        ../Middlewares/Third_Party/LwIP/src/include/netif/ppp;        ../Middlewares/Third_Party/LwIP/src/include/posix;        ../Middlewares/Third_Party/LwIP/src/include/posix/sys;        ../Middlewares/Third_Party/LwIP/system/arch;        ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group SPI_communication
    ../Src/: spi.c
  group Application/MDK-ARM
    ./: startup_stm32f767xx.s
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: dhcp.c ip4_frag.c etharp.c autoip.c ip4_addr.c igmp.c ip4.c icmp.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: ppp.c pppoe.c demand.c eap.c ipcp.c chap-new.c ipv6cp.c eui64.c multilink.c magic.c pppcrypt.c ecp.c fsm.c pppapi.c ccp.c mppe.c vj.c chap_ms.c upap.c auth.c utils.c pppol2tp.c lcp.c pppos.c chap-md5.c
    ../Middlewares/Third_Party/LwIP/src/netif/: slipif.c ethernet.c lowpan6.c
    ../Middlewares/Third_Party/LwIP/src/core/: init.c inet_chksum.c raw.c ip.c netif.c pbuf.c dns.c sys.c def.c tcp_out.c stats.c memp.c udp.c timeouts.c tcp.c mem.c tcp_in.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: dhcp6.c mld6.c icmp6.c nd6.c ethip6.c inet6.c ip6_addr.c ip6_frag.c ip6.c
    ../Middlewares/Third_Party/LwIP/src/api/: netdb.c api_lib.c netifapi.c netbuf.c tcpip.c api_msg.c err.c sockets.c
    ../Middlewares/Third_Party/LwIP/src/apps/httpd/: httpd.c fs.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_tim_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_tim.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_eth.c stm32f7xx_hal_i2c.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_spi.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_adc.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal.c
  group Utils
    ../Src/: utils.c
    ../Inc/: utils.h
  group Application/User
    ../Src/: stm32f7xx_hal_msp.c lwip.c ethernetif.c stm32f7xx_it.c main.c
  group TCP_communication
    ../Src/: cgi_handlers.c tcp_client.c
software components: CMSIS:CORE 4.1.0
